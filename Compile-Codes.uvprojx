# Keil uVision project Compile-Codes.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Compile-Codes
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  asm include: ..\Assembly
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ../Assembly/: SysTick_Initialize.s startup.s exemplo.s
